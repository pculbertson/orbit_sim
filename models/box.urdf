Commit message: added new simulation

File: models/box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry visual mesh filename=file:///home/pculbert/Documents/catkin_ws/src/orbit_sim/mod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
